# IAR project stm8s005_template.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S005K6 STM8S005K6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S005
  ICCSTM8.CCIncludePath2: ..\FWLIB\inc; ..\USER
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: stm8s005_template.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group FWLIB
    ../FWLIB/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
  group USER
    ../USER/: adc.c bluetooth.c device_info.c dl645.c hall.c ht7017.c i2c.c iwatchdog.c key.c led.c lowpower.c main.c motor.c rtc8025t.c spi.c stm8s_it.c tim4.c uart2.c
